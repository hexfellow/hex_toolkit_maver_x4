Commit message: refactor():pid_ctrl & obs_util

File: urdf/maver_x4.urdf (robot description, URDF)
Before this commit: robot maver_x4, 9 links, 8 joints
Links:
- link base_link: mass 43.464 -> 3.464
